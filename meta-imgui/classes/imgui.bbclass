#
# IMGUI compile variables
#

inherit imgui_base

do_install() {
    imgui_do_install
}